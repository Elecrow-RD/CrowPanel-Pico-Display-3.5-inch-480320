# Repository Elecrow-RD/CrowPanel-Pico-Display-3.5-inch-480320

File readme.md:

### 1, Product picture

### 2, Product version number

|      | Hardware | Software | Remark |
| ---- | -------- | -------- | ------ |
| 1    | V1.0     | V1.0     | latest |

### 3, product information

- Main Chip: RP2040
- Processor: Dual-core 32-bit ARM Cortex-M0+ @ 133MHz
- Memory: 264kB on-chip SRAM (supports up to 16MB of off-chip flash memory)
- Screen Size: 3.5 inch
- Resolution: 480*320
- Signal Interface: SPI
- Touch Type: Resistive Touch
- Panel Type: TFT LCD
- Power Input: 5V-2A
- Active Area: 53.64*71.52mm(W * H)
- Dimensions: 62.5 * 104.5 * 13.5mm(W * H * D)

### 4, Use the driver module

| Name | dependency library |
| ---- | ------------------ |
| LVGL | lvgl/lvgl@8.3.3    |

### 5,Quick Start

##### Arduino IDE starts

1.Download the library files used by this product to the 'libraries' folder.

C:\Users\Documents\Arduino\libraries\

2.Open the Arduino IDE

3.Open the code configuration environment and burn it

### 6,Folder structure.

|--Dimensional Drawing: Contains the dimensional drawing file (.dwg) of the hardware.

|--Datasheet: Includes datasheets for components used in the project, providing detailed specifications, electrical characteristics, and pin configurations.

|--Eagle_SCH&PCB: Contains **Eagle CAD** schematic (`.sch`) and PCB layout (`.brd`) files. These are used for circuit design and PCB manufacturing.

|--example: Provides example code and projects to demonstrate how to use the hardware and libraries. These examples help users get started quickly.

|--factory_firmware: Stores pre-compiled factory firmware that can be directly flashed onto the device. This ensures the device runs the default functionality.

|--factory_sourcecode: Contains the source code for the factory firmware, allowing users to modify and rebuild the firmware as needed.

### 7,Pin definition

#define I2C0_SDA 20

#define I2C0_SCL 21

#SD

const int _MISO = 12;  // AKA SPI RX

const int _MOSI = 11;  // AKA SPI TX

const int _CS = 22;

const int _SCK = 10;

## EAGLE design Eagle_SCH&PCB/CrowPanel Pico Display-3.5_V1.0-240412.brd

Parts:
B1: BEEP_5025
C1, C2: 12PF; A_XBJ_0603
C3, C6, C16: 2.2UF; A_XBJ_0603
C4, C5, C7, C8, C9, C10, C11, C12, C13, C14, C35: 100NF; A_XBJ_0603
C15, C17, C20: 47UF; A_XBJ_0805
C18, C19, C31, C33: 22UF; A_XBJ_0805
C21, C28, C42: 1uF; DISCRETE_C0603
C22: 22uF; 0805_S
C23, C43: 100nF; C0603
C30, C38, C39, C40: 100pF; 0603
C32: 100nF; A_XBJ_0603
D1, D2: B5819WT; SOD-523
D3, D15: DISCRETE_007-LED0603; DISCRETE_D0603
D4, D5, D6, D8: SOD-323
J1, J6: CONNECTOR_TWIG-4P-2.0-SMD-FEMALE-REINFORCE90D; CONNECTOR_4P-SMD-2.0-90D
J2: 2.54-16PIN-WOTIE; 2.54-16P-WOTIE
J14, J15: USB_TYPE-C_16PIN3.0USB; KEVIN_3.0TYPEC-SMD
J16: PH2.0WT-2PIN
J17: LXGD-352326-E-Q2; 40PIN-0.5MM
L4: 5.6uH-0530; CD54_CD54
P1, P2, P3, P4, P5, P6, P7, P8, P9, P10, P11, P12, P13, P14, P15, P16, P17, P18, P19, P20, P21, P22, P23, P24, P25, P26, P27, P28, P29, P30, P31, P32, P33, P34, P35, P36, P37, P38, P39, P40, P41, P42, P43, P44, P45, P46, P47, P50, P51, P52, P53, P54, P55, P56, P57, P58, P59, P60, P61, P62: CROWPI_POW_PADPAD-1.0MM; CROWPI_POW_PAD-1.0MM
P48, P49: PADPAD-1.0MM; PAD-1.0MM
Q1, Q2: HXY2102EI; SOT-323_W
Q19: PMOS-3401-4A; SOT-23
R1, R7, R15, R17, R21, R36, R37, R38, R39, R40, R66, R105: 10K; DISCRETE_R0603
R2, R6, R24, R25: 1K; DISCRETE_R0603
R3, R26, R35, R85: 4.7K; DISCRETE_R0603
R4, R27: 3R; DISCRETE_R0603
R5, R70, R83: 0R; DISCRETE_R0603
R8, R14, R23: 10K/NC; DISCRETE_R0603
R9: 0R 5%; DISCRETE_R0603
R10, R11: 22R; DISCRETE_R0603
R12, R13, R68, R69: 5.1K; DISCRETE_R0603
R16, R18, R22: NC; DISCRETE_R0603
R19, R20: 100K1%; DISCRETE_R0603
R81: 45.3K 1%; DISCRETE_R0603
R82: 10K 1%; DISCRETE_R0603
R84: 2K; DISCRETE_R0603
SD1: HOLDER-MICROSD-9P; 9P-SMD-W/-RING
SW1, SW2: KEY-6
T1, T2, T3, T4: 3M-5
U1: RP2040_RP2040; RP2040_QFN-56
U2: SELF_W25Q128JV; SELF_SOIC-8-208MIL
U3: XPT2046; XP2046-SSOP16
U5: 4054A; SOP23-5
U6: HM3416H; CROWBOT_-V1.0-20220525_A_XBJ_SOT23-5
U7: CH340X; MSOP-10_W
X1: 12MHZ_SMD3225; A_XBJ_SMD3225

Connections:
+1V1: C13.1, C14.1, C16.1, U1.23 (VDD_1V1), U1.45 (LDO_OUT), U1.50 (VDD_1V1)
+3V3: C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C15.2, C17.1, C18.2, C20.1, C21.2, C28.2, C33.2, C35.1, C42.2, C43.1, J1.3, J2.16, J6.3, J17.6 (IOVCC), J17.7 (VDD), L4.2, P10.P$1, P13.P$1, P22.P$1, P30.P$1, P43.P$1, R1.2, R3.2, R4.2, R5.2, R7.2, R15.2, R17.2, R21.2, R23.1, R24.2, R25.2, R26.2, R27.2, R35.2, R36.1, R37.1, R38.1, R39.1, R40.1, R81.1, R85.2, R105.2, SD1.4 (VDD), U1.1 (VDDIO), U1.10 (VDDIO), U1.22 (VDDIO), U1.33 (VDDIO), U1.42 (VDDIO), U1.44 (LDO_IN), U1.48 (USB_VDD), U1.49 (VDDIO), U2.8 (VCC), U3.1 (VCC), U3.9 (VREF), U3.10 (IOVDD), U7.7 (VCC), U7.10 (V3)
+5V_UART0: D4.1, D8.1, J15.A4 (VBUS), J15.A9 (VBUS), J15.B4 (VBUS), J15.B9 (VBUS), P26.P$1
+5V_USB: D5.1, D6.1, J14.A4 (VBUS), J14.A9 (VBUS), J14.B4 (VBUS), J14.B9 (VBUS), P2.P$1
AVDD: C3.1, R5.1, U1.43 (ADC_VDD)
BAT+: C19.2, D2.+ (1), J16.P$1, P7.P$1, Q19.3 (D), R20.1, U5.3 (BAT)
BOOT: R6.2, SW2.2
CHG_LED: D15.-, U5.1 (GHRG)
D+: J14.A6 (DP1), J14.B6 (DP2), R11.1
D-: J14.A7 (DN1), J14.B7 (DN2), R10.1
GND: C1.2, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.1, C16.2, C17.2, C18.1, C19.1, C20.2, C21.1, C22.1, C23.2, C28.1, C30.1, C31.1, C32.2, C33.1, C35.2, C38.1, C39.1, C40.1, C42.1, C43.2, D3.-, J1.4, J1.SS1, J1.SS2, J2.15, J6.4, J6.SS1, J6.SS2, J14.A1 (GND), J14.A12 (GND), J14.B1 (GND), J14.B12 (GND), J14.P$6, J14.P$7, J14.P$8, J14.P$9, J15.A1 (GND), J15.A12 (GND), J15.B1 (GND), J15.B12 (GND), J15.P$6, J15.P$7, J15.P$8, J15.P$9, J16.P$2, J16.P$3, J16.P$4, J17.5 (GND1), J17.16 (GND2), J17.37 (GND3), P1.P$1, P6.P$1, P9.P$1, P14.P$1, P21.P$1, P25.P$1, P29.P$1, P42.P$1, P59.P$1, Q1.2 (S), Q2.2 (S), R8.1, R12.2, R13.1, R14.1, R16.1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
GP0/UART0_TX: J2.1, P8.P$1, R70.2, U1.2 (GPIO0)
GP1/UART0_RX: J2.2, P17.P$1, R83.2, U1.3 (GPIO1)
GP2/I2C1_SDA: J2.3, P18.P$1, U1.4 (GPIO2)
GP3/I2C1_SCL: J2.4, P19.P$1, U1.5 (GPIO3)
GP4/UART1_TX: J1.2, J2.5, P20.P$1, P23.P$1, U1.6 (GPIO4)
GP5/UART1_RX: J1.1, J2.6, P24.P$1, P50.P$1, U1.7 (GPIO5)
GP6*I2C1_SDA: J2.7, P51.P$1, U1.8 (GPIO6)
GP7*I2C1_SCL: J2.8, P52.P$1, U1.9 (GPIO7)
GP8/LCD_DC: J17.10 (RS), P34.P$1, U1.11 (GPIO8)
GP9/LCD_CS/SPI_CS0: J17.9 (CS), P35.P$1, U1.12 (GPIO9)
GP10/SPI_CLK/LCD_CLK/TP_CLK/SD_CLK: J17.11 (WR), P32.P$1, P45.P$1, R25.1, SD1.5 (SCLK), U1.13 (GPIO10), U3.16 (DCLK)
GP11/SPI_MOSI/LCD_SDI/TP_SDI/SD_SDI: J17.13 (SDA), P36.P$1, P44.P$1, R24.1, R39.2, SD1.3 (DI), U1.14 (GPIO11), U3.14 (DIN)
GP12/SPI_MISO/LCD_SDO/TP_SDO/SD_SDO: P46.P$1, R40.2, SD1.7 (DO), U1.15 (GPIO12), U3.12 (DOUT)
GP13/LCD_BL: U1.16 (GPIO13)
GP14/BUZZER: Q2.1 (G), R14.2, U1.17 (GPIO14)
GP15/LCD_RST: J17.15 (REST), P5.P$1, U1.18 (GPIO15)
GP16/TP_CS/SPI_CS1: U1.27 (GPIO16), U3.15 (CS)
GP17/TP_IRQ: R105.1, U1.28 (GPIO17), U3.11 (PENIRQ)
GP18/LCD_BL_PWM: Q1.1 (G), R8.2, U1.29 (GPIO18)
GP19*: J2.9, P53.P$1, U1.30 (GPIO19)
GP20/I2C0_SDA: J2.10, J6.2, P15.P$1, P54.P$1, R3.1, U1.31 (GPIO20)
GP21/I2C0_SCL: J2.11, J6.1, P16.P$1, P55.P$1, R26.1, U1.32 (GPIO21)
GP22/SD_CS/SPI_CS2: P47.P$1, R36.2, SD1.2 (CS), U1.34 (GPIO22)
GP23*: U1.35 (GPIO23)
GP24*: U1.36 (GPIO24)
GP25/LED: U1.37 (GPIO25)
GP26*ADC0*I2C1_SDA: J2.12, P56.P$1, U1.38 (GPIO26/ADC0)
GP27*ADC1*I2C1_SCL: J2.13, P57.P$1, U1.39 (GPIO27/ADC1)
GP28*ADC2: J2.14, P58.P$1, U1.40 (GPIO28/ADC2)
GP29/BAT+_ADC3: R19.1, R20.2, U1.41 (GPIO29/ADC3)
IM0: J17.38 (IM0), P60.P$1, R15.1, R16.2
IM1: J17.39 (IM1), P61.P$1, R17.1, R18.2
IM2: J17.40 (IM2), P62.P$1, R21.1, R22.2
LED-A: J17.33 (LEDA), P40.P$1, R27.1
LED-K: J17.34 (LEDK1), J17.35 (LEDK2), J17.36 (LEDK3), P41.P$1, R9.2
unnamed: C2.2, R2.1, X1.3 (XOUT)
unnamed: R2.2, U1.21 (XOUT)
unnamed: C1.1, U1.20 (XIN), X1.1 (XIN)
unnamed: B1.1 (+), D1.- (2), R4.1
unnamed: J15.B5 (CC2), R68.1
unnamed: B1.2 (-), D1.+ (1), Q2.3 (D)
unnamed: Q1.3 (D), R9.1
unnamed: R84.1, U5.5 (PROG)
unnamed: L4.1, U6.3 (SW)
unnamed: J14.A5 (CC1), R13.2
unnamed: D15.+, R85.1
unnamed: J15.A5 (CC1), R69.2
unnamed: J14.B5 (CC2), R12.1
unnamed: R23.2, U3.7 (VBAT)
unnamed: R37.2, SD1.1 (DATA2)
unnamed: R38.2, SD1.8 (DATA1)
unnamed: R70.1, U7.9 (RXD)
unnamed: R83.1, U7.8 (TXD)
unnamed: D3.+, R35.1
unnamed: R81.2, R82.2, U6.5 (FB)
QSPI_CS: R6.1, R7.1, U1.56 (QSPI_!CS!), U2.1 (/CS)
QSPI_D0: U1.53 (QSPI_SD0), U2.5 (DI(IO0))
QSPI_D1: U1.55 (QSPI_SD1), U2.2 (DO(IO1))
QSPI_D2: U1.54 (QSPI_SD2), U2.3 (/WP(IO2))
QSPI_D3: U1.51 (QSPI_SD3), U2.7 (/HOLD/RESET(IO3))
QSPI_SCK: U1.52 (QSPI_SCLK), U2.6 (CLK)
RESET: C4.1, P31.P$1, R1.1, SW1.2, U1.26 (RUN)
SWCLK: P11.P$1, U1.24 (SWCLK)
SWDIO: P12.P$1, U1.25 (SWDIO)
TP_X+: C30.2, J17.1 (XL), P33.P$1, U3.2 (XP)
TP_X-: C39.2, J17.3 (XR), P38.P$1, U3.4 (XN)
TP_Y+: C38.2, J17.4 (YD), P39.P$1, U3.3 (YP)
TP_Y-: C40.2, J17.2 (YU), P37.P$1, U3.5 (YN)
UART_USB_D+: J15.A6 (DP1), J15.B6 (DP2), P27.P$1, U7.1 (D+)
UART_USB_D-: J15.A7 (DN1), J15.B7 (DN2), P28.P$1, U7.2 (D-)
USB_D+: P3.P$1, R11.2, U1.47 (USB_D+)
USB_D-: P4.P$1, R10.2, U1.46 (USB_D-)
VBAT_IN: C22.2, C23.1, D4.2, D5.2, Q19.1 (G), R66.2, U5.4 (VCC)
VIN: C31.2, C32.1, D2.- (2), D6.2, D8.2, Q19.2 (S), U6.1 (EN), U6.4 (VIN)

Notes on the sheet:
RP2040_MCU MIN System
Buzzer
LED Indicator
3.3V电源，GPIO排针
Vout=0.6*(R20/R21 +1)=3.3V
Boot:
RESET=0时，按下Boot-下载模式
Boot=1,正常运行
PWR
W25Q32
Type-C->URAT0
电池及充电电路
500mA
BAT
Type-C->USB
LCD+TP 接口
TP驱动:XPT2046
TF Card
UART1接口
LCD 背光
POWER
Mark
HM3416H更换为RY3420

Board: 2 copper layers, 101.5 x 59.5 mm, 173 parts (60 on the bottom side), 81 nets.
